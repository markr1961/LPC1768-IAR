<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LPC1768-LAR.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>LPC1768-LAR</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>LPC1768-LAR</project>
        <configuration>RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


